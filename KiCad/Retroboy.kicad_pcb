File: KiCad/Retroboy.kicad_pcb (KiCad board)
At the start: 2 copper layers, 1 part, among them J1 1473005-1

Commit message: Updates.
Parts:
- removed J1: 1473005-1, TE_1473005-1:TE_1473005-1
